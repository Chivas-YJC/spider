Commit message: init

File: src/spider_description/urdf/spider_o.urdf (robot description, URDF)
Before this commit: robot spider, 20 links, 19 joints
Joints:
- joint left-front-coxae: axis 0 1 0 -> 0 0 0
